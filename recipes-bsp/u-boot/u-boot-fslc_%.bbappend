FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-default-boot-from-sd.patch"
